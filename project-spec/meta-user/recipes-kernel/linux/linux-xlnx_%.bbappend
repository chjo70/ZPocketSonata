SRC_URI += "file://user_2021-01-06-18-33-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

